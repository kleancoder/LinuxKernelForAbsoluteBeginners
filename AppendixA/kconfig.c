## AppendixA/kconfig.c
```kconfig
config AUDIT
      bool "Auditing support"
      depends on NET
      help
        The help text. Blah blah blah. 
```
